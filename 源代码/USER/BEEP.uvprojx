# Keil uVision project BEEP.uvprojx, settings and files
target BEEP (5060960::V5.06 update 7 (build 960)::.\ARMCC5)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BEEP +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\BEEP;..\HARDWARE\SWITCH;..\HARDWARE\NET;..\HARDWARE\NET\EDP;..\HARDWARE\usart2;..\HARDWARE\bh1750;..\HARDWARE\IIC;..\HARDWARE\TIM;..\HARDWARE\LCD
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/SWITCH/: SWITCH.c
    ../HARDWARE/NET/: esp8266.c onenet.c
    ../HARDWARE/NET/EDP/: EdpKit.c
    ../HARDWARE/usart2/: usart2.c
    ../HARDWARE/bh1750/: bh1750.c
    ../HARDWARE/LCD/: adc.c dht11.c key.c
    ../HARDWARE/IIC/: IIC.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_spi.c stm32f10x_bkp.c stm32f10x_pwr.c
  group README
    ../: README.TXT
  group LCD
    ../HARDWARE/LCD/: GUI.c Lcd_Driver.c
